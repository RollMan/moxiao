# Repository RollMan/moxiao

## KiCad design hpamp_combo.kicad_pcb

Parts:
C1, C2, C3, C4, C7, C8, C9, C10, C309, C310: 100n; C_Disc_D3.0mm_W2.0mm_P2.50mm; MPN X7R 50V 2.54mm
C101, C201: 100p; C_Disc_D3.0mm_W2.0mm_P2.50mm; MPN RD15N101J1HL2L (NP0)
C102, C202: 22p; C_Disc_D3.0mm_W2.0mm_P2.50mm; MPN RD15N220J1HL2L (NP0)
C103, C203: 1u; C_Rect_L7.2mm_W4.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2; MPN MEM105J101RB-5 (ポリエステル 100V)
C301, C307, C308: 100u 25V; CP_Radial_D5.0mm_P2.00mm; MPN ルビコン 25PX100MEFC5X11
C302, C303, C304: 4.7u 50V; C_Disc_D5.0mm_W2.5mm_P5.00mm; MPN 村田 RDEC71H475K2K1H03B (X7S, 5mm)
C305, C306: 33u 50V; CP_Radial_D5.0mm_P2.00mm; MPN ルビコン 50PX33MEFC5X11
D101, D102, D201, D202: S-562T; CRD_SEMITEC_S-series; MPN SEMITEC S-562T (5.6mA)
D301: 1N5819; D_DO-41_SOD81_P10.16mm_Horizontal; MPN 1N5819 / SB140 など (40V 1A, DO-41)
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1, J2: Jack; Jack_3.5mm_Marushin_MJ-8435; MPN マル信 MJ-8435
J301: DC IN 12V; DCJack_Marushin_MJ-179PH; MPN マル信 MJ-179PH (2.1mm, センター+)
L301, L302: 10uH; L_Axial_L12.0mm_D5.0mm_P15.24mm_Horizontal_Fastron_MISC; MPN AL0510-100K (10µH 250mΩ)
LED301: LED; LED_D3.0mm; MPN 3mm LED
NT1: STAR; NetTie-3_SMD_Pad2.0mm
PS301: MCWI03-12D15; Minmax_MCWI03_SIP8; MPN Minmax MCWI03-12D15 (3W, 4.5-18V in, ±1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
Q101, Q201: TMBT3906; SOT-23_HandSolder; MPN Toshiba TMBT3906
Q102, Q202: TMBT3904; SOT-23_HandSolder; MPN Toshiba TMBT3904
Q103, Q203: TTC501; SOT-23_HandSolder; MPN Toshiba TTC501 (SOT-23F)
Q104, Q204: TTA501; SOT-23_HandSolder; MPN Toshiba TTA501 (SOT-23F)
R101, R103, R201, R203: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; MPN 金属皮膜 1/4W 1% 1kΩ (標準サイズ φ2.5×6.3mm)
R102, R202: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; MPN 金属皮膜 1/4W 1% 22kΩ (標準サイズ φ2.5×6.3mm)
R104, R204: 3.9k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; MPN 金属皮膜 1/4W 1% 3.9kΩ (標準サイズ φ2.5×6.3mm)
R105, R106, R107, R205, R206, R207: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; MPN 金属皮膜 1/4W 1% 100Ω (標準サイズ φ2.5×6.3mm)
R108, R109, R208, R209: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; MPN 金属皮膜 1/4W 1% 10Ω (標準サイズ φ2.5×6.3mm)
R110, R210: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; MPN 金属皮膜 1/4W 1% 1MΩ (標準サイズ φ2.5×6.3mm)
R301: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; MPN 金属皮膜 1/4W 1% 4.7kΩ (標準サイズ φ2.5×6.3mm)
RV1: 10kA x2; Potentiometer_Alps_RK097_Dual_Horizontal; MPN ALPS RK0971220-F15-C0-A103
U1: MUSES8920AE; SOIC-8_3.9x4.9mm_P1.27mm; MPN MUSES8920AE
U2: TL072; DIP-8_W7.62mm; MPN TL072CP / LF412 / NJM072BD など (JFET 入力,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
U301: LM78L12; TO-92_Inline_Wide; MPN LM78L12 (TO-92)
U302: LM79L12; TO-92_Inline_Wide; MPN LM79L12 (TO-92)

Connections:
+12V: C1.1, C3.1, C7.1, C9.1, C307.1, C309.1, D101.2 (A), D201.2 (A), Q102.3 (C), Q103.3 (C), Q202.3 (C), Q203.3 (C), R301.1, U1.8 (V+), U2.8 (V+), U301.1 (VO)
+15V: C303.1, L301.1, PS301.6 (+Vout)
-12V: C2.2, C4.2, C8.2, C10.2, C308.2, C310.2, D102.1 (K), D202.1 (K), Q101.3 (C), Q104.3 (C), Q201.3 (C), Q204.3 (C), U1.4 (V-), U2.4 (V-), U302.3 (VO)
-15V: C304.2, L302.1, PS301.8 (-Vout)
/IN_L: J1.T, RV1.3
/IN_R: J1.R, RV1.6
/N15F: C306.2, L302.2, U302.2 (VI)
/OUT_L: C102.2, J2.T, R104.2, R108.2, R109.1, R110.1
/OUT_R: C202.2, J2.R, R204.2, R208.2, R209.1, R210.1
/P15F: C305.1, L301.2, U301.3 (VI)
/SRV_L: C103.2, R102.2, U2.1
/SRV_R: C203.2, R202.2, U2.7
/VIN+: C301.1, C302.1, D301.1 (K), PS301.2 (+Vin)
/VIN-: C301.2, C302.2, J301.2, PS301.1 (-Vin)
/WIP_L: R101.1, RV1.2
/WIP_R: R201.1, RV1.5
unnamed: D101.1 (K), Q101.2 (E), R106.1
unnamed: D102.2 (A), Q102.2 (E), R107.1
unnamed: D201.1 (K), Q201.2 (E), R206.1
unnamed: D202.2 (A), Q202.2 (E), R207.1
unnamed: D301.2 (A), J301.1
unnamed: LED301.2 (A), R301.2
unnamed: Q101.1 (B), Q102.1 (B), R105.2
unnamed: Q103.1 (B), R106.2
unnamed: Q103.2 (E), R108.1
unnamed: Q104.1 (B), R107.2
unnamed: Q104.2 (E), R109.2
unnamed: Q201.1 (B), Q202.1 (B), R205.2
unnamed: Q203.1 (B), R206.2
unnamed: Q203.2 (E), R208.1
unnamed: Q204.1 (B), R207.2
unnamed: Q204.2 (E), R209.2
unnamed: R105.1, U1.1
unnamed: R205.1, U1.7
unnamed: C101.1, R101.2, R102.1, U1.3 (+)
unnamed: C102.1, R103.1, R104.1, U1.2 (-)
unnamed: C201.1, R201.2, R202.1, U1.5 (+)
unnamed: C202.1, R203.1, R204.1, U1.6 (-)
unnamed: C103.1, R110.2, U2.2 (-)
unnamed: C203.1, R210.2, U2.6 (-)
OGND: J2.S, NT1.3
PGND: C1.2, C2.1, C3.2, C4.1, C7.2, C8.1, C9.2, C10.1, C303.2, C304.1, C305.2, C306.1, C307.2, C308.1, C309.2, C310.1, LED301.1 (K), NT1.2, PS301.7 (Com), U301.2 (GND), U302.1 (GND)
SGND: C101.2, C201.2, J1.S, NT1.1, R103.2, R203.2, RV1.1, RV1.4, U2.3 (+), U2.5 (+)

Notes on the sheet:
Power / ground (star point)
Headphone out
Output bias: V(R108) + V(R109) = Iq x 20 ohm (target 5-10 mA) CRD S-562T (5.6 mA) -> S-103T (10 mA) if more bias is wanted
Input / Volume
DC servo
Gain = 1 + R104/R103 = 4.9 (13.8 dB) DC servo: U2 inverting integrator (R110, C103, tau = 1 s) -> R102 -> +IN
Ctrl (pin 3) open = ON
Output stage decoupling / bulk (PGND)
MCWI03-12D15: 入力 4.5–18V (12V アダプタをそのまま使用, 24V 不可). 出力 ±15V, 各出力の容量負荷 ≤ 47µF (C3+C5 = 37.7µF).
Channel L
ON-BOARD PSU (isolated DC-DC)
VIN- (入力側) と GND (出力側 Com) は絶縁。基板上でもつながない。最小負荷 ±25mA (アンプ接続時 約 50–60mA).
GND: SGND = input/volume/Rg/servo ref, OGND = headphone sleeve only, PGND = supply/decoupling. Joined only at NT1 near the PSU outputs.
INPUT side (VIN-) — isolated —
SGND / PGND / OGND are joined only here (NT1, next to the PSU outputs)
OUTPUT side (GND = DC-DC Com)
CW = pin3/6 (IN), CCW = pin1/4 (SGND)
+12V / -12V / PGND come from the on-board PSU section (U301 / U302)
Channel R

Board: 2 copper layers, 96.3 x 77.0 mm, 75 parts (0 on the bottom side), 43 nets.
